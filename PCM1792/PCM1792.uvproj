# Keil uVision project PCM1792.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: PCM1792 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\PCM1792;.\UART;.\IIC;.\DELAY
  group MAIN
    ./: define.h MAIN_code.c
  group UART
    ./UART/: UART.c
  group IIC
    ./IIC/: IIC.c
  group DELAY
    ./DELAY/: DELAY.c
  group DOC
    ./DOC/: README.txt
